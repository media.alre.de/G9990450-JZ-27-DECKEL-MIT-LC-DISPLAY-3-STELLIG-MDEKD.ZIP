Properties of the parts of a building model (IFC2X3)

# File
Description: LC-Display 3 ½ stellig für MDEKD, ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: G9990450, LC-Display 3 ½ stellig für MDEKD
In: Raum
Description: Deckel mit LC-Display 3 ½ stellig für Druckmessumformer MDEKD; Classification: EC011650 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: G9990450; ModelLabel: JZ-27; GlobalTradeItemNumber: 4050528044372; ProductURL: https://alre.de/produkt_G9990450
Pset_Specification - NominalLength: 0.067 m; NominalWidth: 0.056 m; NominalDepth: 0.015 m; NetWeight: 0.07
Pset_ALRE_ETIM_Properties - Art des Zubehörs/Ersatzteils: sonstige; Zubehör: yes; ETIM-Klasse: EC011650; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-G9990450.pdf
